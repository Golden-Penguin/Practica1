options:
  parameters:
    author: MiguelBuitrago_JeanRodrigez
    copyright: UIS
    generate_options: qt_gui
    id: Practica1Parte3
    output_language: python
    title: Parte3
  states: {}

blocks:
- name: samp_rate
  id: variable
  parameters:
    value: 100e3
  states: {}
- name: analog_sig_source_x_0
  id: analog_sig_source_x
  parameters:
    amp: '1'
    freq: 11E3
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: float
    waveform: analog.GR_COS_WAVE
  states: {}
- name: analog_sig_source_x_1
  id: analog_sig_source_x
  parameters:
    amp: '1'
    freq: 24e3
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: float
    waveform: analog.GR_COS_WAVE
  states: {}
- name: analog_sig_source_x_2
  id: analog_sig_source_x
  parameters:
    amp: '1'
    freq: 15e3
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: float
    waveform: analog.GR_COS_WAVE
  states: {}
- name: blocks_multiply_xx_0
  id: blocks_multiply_xx
  parameters:
    num_inputs: '3'
    type: float
  states: {}
- name: blocks_throttle_0
  id: blocks_throttle
  parameters:
    samples_per_second: samp_rate
    type: float
  states: {state: bypassed}
- name: blocks_throttle_1
  id: blocks_throttle
  parameters:
    samples_per_second: samp_rate
    type: float
  states: {}
- name: qtgui_freq_sink_x_1
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    name: QT GUI Plot
    nconnections: '3'
    type: float
    wintype: firdes.WIN_BLACKMAN_hARRIS
  states: {state: disabled}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    name: QT GUI Plot
    nconnections: '3'
    size: '1024'
    srate: samp_rate
    type: float
  states: {state: disabled}
- name: rational_resampler_xxx_0
  id: rational_resampler_xxx
  parameters:
    decim: '1'
    fbw: '0.1'
    interp: '1'
    taps: ''
    type: fff
  states: {state: disabled}
- name: rational_resampler_xxx_1
  id: rational_resampler_xxx
  parameters:
    decim: '1'
    fbw: '0.1'
    interp: '4'
    taps: ''
    type: fff
  states: {state: disabled}
- name: rational_resampler_xxx_2
  id: rational_resampler_xxx
  parameters:
    decim: '4'
    fbw: '0.1'
    interp: '1'
    taps: ''
    type: fff
  states: {state: disabled}

connections:
- [analog_sig_source_x_0, '0', blocks_multiply_xx_0, '0']
- [analog_sig_source_x_0, '0', rational_resampler_xxx_0, '0']
- [analog_sig_source_x_1, '0', blocks_multiply_xx_0, '1']
- [analog_sig_source_x_1, '0', rational_resampler_xxx_1, '0']
- [analog_sig_source_x_2, '0', blocks_multiply_xx_0, '2']
- [analog_sig_source_x_2, '0', rational_resampler_xxx_2, '0']
- [blocks_multiply_xx_0, '0', blocks_throttle_1, '0']
- [rational_resampler_xxx_0, '0', blocks_throttle_0, '0']
- [rational_resampler_xxx_1, '0', qtgui_freq_sink_x_1, '1']
- [rational_resampler_xxx_1, '0', qtgui_time_sink_x_0, '1']
- [rational_resampler_xxx_2, '0', qtgui_freq_sink_x_1, '2']
- [rational_resampler_xxx_2, '0', qtgui_time_sink_x_0, '2']

metadata:
  file_format: 1
